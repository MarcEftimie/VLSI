v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 1110 -2600 1110 -2590 {
lab=VDD}
N 770 -2600 770 -2590 {
lab=VDD}
N 890 -2600 890 -2590 {
lab=VDD}
N 990 -2600 990 -2590 {
lab=VDD}
N 920 -2560 960 -2560 {
lab=#net1}
N 800 -2560 810 -2560 {
lab=#net2}
N 810 -2560 810 -2520 {
lab=#net2}
N 810 -2520 990 -2520 {
lab=#net2}
N 990 -2530 990 -2520 {
lab=#net2}
N 1070 -2560 1080 -2560 {
lab=#net2}
N 1070 -2560 1070 -2520 {
lab=#net2}
N 990 -2520 1070 -2520 {
lab=#net2}
N 940 -2560 940 -2510 {
lab=#net1}
N 890 -2510 940 -2510 {
lab=#net1}
N 890 -2530 890 -2510 {
lab=#net1}
N 890 -2510 890 -2500 {
lab=#net1}
N 1110 -2530 1110 -2500 {
lab=Vbn}
N 1070 -2510 1110 -2510 {
lab=Vbn}
N 1070 -2510 1070 -2470 {
lab=Vbn}
N 1070 -2470 1080 -2470 {
lab=Vbn}
N 990 -2520 990 -2500 {
lab=#net2}
N 1020 -2470 1070 -2470 {
lab=Vbn}
N 770 -2530 770 -2500 {
lab=#net3}
N 770 -2510 810 -2510 {
lab=#net3}
N 810 -2510 810 -2470 {
lab=#net3}
N 800 -2470 860 -2470 {
lab=#net3}
N 890 -2440 890 -2370 {
lab=GND}
N 990 -2440 990 -2370 {
lab=GND}
N 770 -2380 770 -2370 {
lab=GND}
N 1110 -2380 1110 -2370 {
lab=GND}
N 1110 -2440 1110 -2390 {
lab=GND}
N 1110 -2390 1110 -2380 {
lab=GND}
N 1110 -2510 1120 -2510 {
lab=Vbn}
N 770 -2370 890 -2370 {
lab=GND}
N 890 -2370 990 -2370 {
lab=GND}
N 990 -2370 1100 -2370 {
lab=GND}
N 1100 -2370 1110 -2370 {
lab=GND}
N 770 -2600 890 -2600 {
lab=VDD}
N 890 -2600 990 -2600 {
lab=VDD}
N 990 -2600 1110 -2600 {
lab=VDD}
N 1320 -2730 1320 -2720 {
lab=#net4}
N 1320 -2720 1560 -2720 {
lab=#net4}
N 1560 -2730 1560 -2720 {
lab=#net4}
N 1480 -2730 1480 -2720 {
lab=#net4}
N 1400 -2730 1400 -2720 {
lab=#net4}
N 1430 -2760 1450 -2760 {
lab=#net4}
N 1440 -2760 1440 -2720 {
lab=#net4}
N 1350 -2760 1370 -2760 {
lab=#net5}
N 1510 -2760 1530 -2760 {
lab=#net5}
N 1360 -2860 1360 -2760 {
lab=#net5}
N 1360 -2860 1520 -2860 {
lab=#net5}
N 1520 -2860 1520 -2760 {
lab=#net5}
N 1290 -2760 1290 -2700 {
lab=#net6}
N 1290 -2700 1590 -2700 {
lab=#net6}
N 1590 -2760 1590 -2700 {
lab=#net6}
N 1730 -2730 1730 -2720 {
lab=#net6}
N 1730 -2720 1970 -2720 {
lab=#net6}
N 1970 -2730 1970 -2720 {
lab=#net6}
N 1890 -2730 1890 -2720 {
lab=#net6}
N 1810 -2730 1810 -2720 {
lab=#net6}
N 1840 -2760 1860 -2760 {
lab=#net7}
N 1760 -2760 1780 -2760 {
lab=#net5}
N 1920 -2760 1940 -2760 {
lab=#net5}
N 1770 -2860 1770 -2760 {
lab=#net5}
N 1770 -2860 1930 -2860 {
lab=#net5}
N 1930 -2860 1930 -2760 {
lab=#net5}
N 1700 -2760 1700 -2700 {
lab=#net8}
N 1700 -2700 2000 -2700 {
lab=#net8}
N 2000 -2760 2000 -2700 {
lab=#net8}
N 1850 -2760 1850 -2580 {
lab=#net7}
N 1440 -2720 1440 -2620 {
lab=#net4}
N 1440 -2620 1440 -2600 {
lab=#net4}
N 1320 -2580 1320 -2570 {
lab=#net8}
N 1560 -2580 1560 -2570 {
lab=#net8}
N 1400 -2580 1400 -2570 {
lab=#net8}
N 1430 -2540 1450 -2540 {
lab=#net9}
N 1480 -2580 1480 -2570 {
lab=#net8}
N 1320 -2580 1560 -2580 {
lab=#net8}
N 1370 -2580 1370 -2540 {
lab=#net8}
N 1510 -2580 1510 -2540 {
lab=#net8}
N 1440 -2540 1440 -2530 {
lab=#net9}
N 1440 -2470 1440 -2440 {
lab=#net10}
N 1590 -2600 1590 -2540 {
lab=#net4}
N 1290 -2600 1590 -2600 {
lab=#net4}
N 1290 -2600 1290 -2540 {
lab=#net4}
N 1530 -2540 1530 -2440 {
lab=#net10}
N 1350 -2440 1530 -2440 {
lab=#net10}
N 1350 -2540 1350 -2440 {
lab=#net10}
N 1560 -2620 1560 -2580 {
lab=#net8}
N 1560 -2620 1700 -2620 {
lab=#net8}
N 1700 -2700 1700 -2620 {
lab=#net8}
N 1730 -2580 1730 -2570 {
lab=#net7}
N 1970 -2580 1970 -2570 {
lab=#net7}
N 1810 -2580 1810 -2570 {
lab=#net7}
N 1840 -2540 1860 -2540 {
lab=#net10}
N 1890 -2580 1890 -2570 {
lab=#net7}
N 1730 -2580 1970 -2580 {
lab=#net7}
N 1780 -2580 1780 -2540 {
lab=#net7}
N 1920 -2580 1920 -2540 {
lab=#net7}
N 2000 -2600 2000 -2540 {
lab=#net6}
N 1700 -2600 2000 -2600 {
lab=#net6}
N 1700 -2600 1700 -2540 {
lab=#net6}
N 1940 -2540 1940 -2440 {
lab=#net10}
N 1760 -2440 1940 -2440 {
lab=#net10}
N 1760 -2540 1760 -2440 {
lab=#net10}
N 1850 -2540 1850 -2440 {
lab=#net10}
N 1590 -2700 1590 -2640 {
lab=#net6}
N 1590 -2640 1810 -2640 {
lab=#net6}
N 1810 -2720 1810 -2640 {
lab=#net6}
N 1810 -2640 1810 -2600 {
lab=#net6}
N 1520 -2860 1770 -2860 {
lab=#net5}
N 1530 -2440 1760 -2440 {
lab=#net10}
N 520 -2960 520 -2950 {
lab=#net11}
N 550 -2920 570 -2920 {
lab=#net12}
N 600 -2960 600 -2950 {
lab=#net11}
N 470 -2920 490 -2920 {
lab=#net11}
N 630 -2920 650 -2920 {
lab=#net11}
N 680 -2960 680 -2950 {
lab=#net11}
N 440 -2960 440 -2950 {
lab=#net11}
N 310 -2920 330 -2920 {
lab=#net11}
N 390 -2920 410 -2920 {
lab=#net12}
N 360 -2960 360 -2950 {
lab=#net11}
N 280 -2960 280 -2950 {
lab=#net11}
N 790 -2920 810 -2920 {
lab=#net11}
N 840 -2960 840 -2950 {
lab=#net11}
N 760 -2960 760 -2950 {
lab=#net11}
N 710 -2920 730 -2920 {
lab=#net12}
N 250 -2920 250 -2820 {
lab=#net12}
N 250 -2820 870 -2820 {
lab=#net12}
N 870 -2920 870 -2820 {
lab=#net12}
N 720 -2920 720 -2820 {
lab=#net12}
N 560 -2920 560 -2820 {
lab=#net12}
N 400 -2920 400 -2820 {
lab=#net12}
N 320 -2960 320 -2920 {
lab=#net11}
N 480 -2960 480 -2920 {
lab=#net11}
N 640 -2960 640 -2920 {
lab=#net11}
N 800 -2960 800 -2920 {
lab=#net11}
N 230 -2920 230 -2760 {
lab=#net13}
N 230 -2760 890 -2760 {
lab=#net13}
N 890 -2920 890 -2760 {
lab=#net13}
N 200 -2960 200 -2950 {
lab=#net11}
N 920 -2960 920 -2950 {
lab=#net11}
N 200 -2960 920 -2960 {
lab=#net11}
N 950 -2980 950 -2920 {
lab=#net14}
N 170 -2980 950 -2980 {
lab=#net14}
N 170 -2980 170 -2920 {
lab=#net14}
N 210 -1320 210 -1310 {
lab=#net15}
N 210 -1310 450 -1310 {
lab=#net15}
N 450 -1320 450 -1310 {
lab=#net15}
N 370 -1320 370 -1310 {
lab=#net15}
N 290 -1320 290 -1310 {
lab=#net15}
N 320 -1350 340 -1350 {
lab=#net15}
N 330 -1350 330 -1310 {
lab=#net15}
N 240 -1350 260 -1350 {
lab=VDD}
N 400 -1350 420 -1350 {
lab=VDD}
N 250 -1450 250 -1350 {
lab=VDD}
N 250 -1450 410 -1450 {
lab=VDD}
N 410 -1450 410 -1350 {
lab=VDD}
N 180 -1350 180 -1290 {
lab=#net16}
N 180 -1290 480 -1290 {
lab=#net16}
N 480 -1350 480 -1290 {
lab=#net16}
N 690 -1320 690 -1310 {
lab=#net16}
N 690 -1310 930 -1310 {
lab=#net16}
N 930 -1320 930 -1310 {
lab=#net16}
N 850 -1320 850 -1310 {
lab=#net16}
N 770 -1320 770 -1310 {
lab=#net16}
N 800 -1350 820 -1350 {
lab=#net17}
N 720 -1350 740 -1350 {
lab=VDD}
N 880 -1350 900 -1350 {
lab=VDD}
N 730 -1450 730 -1350 {
lab=VDD}
N 730 -1450 890 -1450 {
lab=VDD}
N 890 -1450 890 -1350 {
lab=VDD}
N 660 -1350 660 -1290 {
lab=#net18}
N 660 -1290 960 -1290 {
lab=#net18}
N 960 -1350 960 -1290 {
lab=#net18}
N 530 -1150 530 -1140 {
lab=#net18}
N 560 -1110 580 -1110 {
lab=#net19}
N 610 -1150 610 -1140 {
lab=#net18}
N 480 -1110 500 -1110 {
lab=#net18}
N 640 -1110 660 -1110 {
lab=#net18}
N 690 -1150 690 -1140 {
lab=#net18}
N 450 -1150 450 -1140 {
lab=#net18}
N 320 -1110 340 -1110 {
lab=#net18}
N 400 -1110 420 -1110 {
lab=#net19}
N 370 -1150 370 -1140 {
lab=#net18}
N 290 -1150 290 -1140 {
lab=#net18}
N 800 -1110 820 -1110 {
lab=#net18}
N 850 -1150 850 -1140 {
lab=#net18}
N 770 -1150 770 -1140 {
lab=#net18}
N 720 -1110 740 -1110 {
lab=#net19}
N 260 -1110 260 -1010 {
lab=#net19}
N 730 -1110 730 -1010 {
lab=#net19}
N 570 -1110 570 -1010 {
lab=#net19}
N 410 -1110 410 -1010 {
lab=#net19}
N 330 -1150 330 -1110 {
lab=#net18}
N 490 -1150 490 -1110 {
lab=#net18}
N 650 -1150 650 -1110 {
lab=#net18}
N 810 -1150 810 -1110 {
lab=#net18}
N 240 -1110 240 -950 {
lab=GND}
N 1540 -1110 1540 -950 {
lab=GND}
N 210 -1150 210 -1140 {
lab=#net18}
N 1570 -1150 1570 -1140 {
lab=#net18}
N 1600 -1170 1600 -1110 {
lab=#net15}
N 180 -1170 180 -1110 {
lab=#net15}
N 330 -1310 330 -1170 {
lab=#net15}
N 130 -1390 130 -1380 {
lab=VDD}
N 90 -1390 130 -1390 {
lab=VDD}
N 90 -1390 90 -1350 {
lab=VDD}
N 90 -1350 100 -1350 {
lab=VDD}
N 130 -1350 130 -1340 {
lab=VDD}
N 90 -1340 130 -1340 {
lab=VDD}
N 90 -1350 90 -1340 {
lab=VDD}
N 90 -1400 90 -1390 {
lab=VDD}
N 160 -1350 180 -1350 {
lab=#net16}
N 960 -1350 980 -1350 {
lab=#net18}
N 1010 -1390 1010 -1380 {
lab=VDD}
N 1010 -1390 1050 -1390 {
lab=VDD}
N 1050 -1390 1050 -1350 {
lab=VDD}
N 1040 -1350 1050 -1350 {
lab=VDD}
N 1010 -1350 1010 -1340 {
lab=VDD}
N 1010 -1340 1050 -1340 {
lab=VDD}
N 1050 -1350 1050 -1340 {
lab=VDD}
N 1050 -1400 1050 -1390 {
lab=VDD}
N 160 -1110 180 -1110 {
lab=#net15}
N 130 -1110 130 -1100 {
lab=GND}
N 90 -1100 130 -1100 {
lab=GND}
N 90 -1110 90 -1100 {
lab=GND}
N 90 -1110 100 -1110 {
lab=GND}
N 130 -1150 130 -1140 {
lab=GND}
N 90 -1150 130 -1150 {
lab=GND}
N 90 -1150 90 -1110 {
lab=GND}
N 90 -1100 90 -1090 {
lab=GND}
N 1600 -1110 1620 -1110 {
lab=#net15}
N 1650 -1150 1650 -1140 {
lab=GND}
N 1650 -1150 1690 -1150 {
lab=GND}
N 1690 -1150 1690 -1110 {
lab=GND}
N 1680 -1110 1690 -1110 {
lab=GND}
N 1650 -1110 1650 -1100 {
lab=GND}
N 1650 -1100 1690 -1100 {
lab=GND}
N 1690 -1110 1690 -1100 {
lab=GND}
N 1690 -1100 1690 -1090 {
lab=GND}
N 610 -1390 610 -1380 {
lab=VDD}
N 570 -1390 610 -1390 {
lab=VDD}
N 570 -1350 580 -1350 {
lab=VDD}
N 610 -1350 610 -1340 {
lab=VDD}
N 570 -1340 610 -1340 {
lab=VDD}
N 640 -1350 660 -1350 {
lab=#net18}
N 480 -1350 500 -1350 {
lab=#net16}
N 530 -1390 530 -1380 {
lab=VDD}
N 530 -1390 570 -1390 {
lab=VDD}
N 570 -1390 570 -1350 {
lab=VDD}
N 560 -1350 570 -1350 {
lab=VDD}
N 530 -1350 530 -1340 {
lab=VDD}
N 530 -1340 570 -1340 {
lab=VDD}
N 570 -1350 570 -1340 {
lab=VDD}
N 570 -1400 570 -1390 {
lab=VDD}
N 660 -1290 660 -1150 {
lab=#net18}
N 1810 -1150 1810 -1140 {
lab=#net17}
N 2050 -1150 2050 -1140 {
lab=#net17}
N 1890 -1150 1890 -1140 {
lab=#net17}
N 1920 -1110 1940 -1110 {
lab=GND}
N 1970 -1150 1970 -1140 {
lab=#net17}
N 1810 -1150 2050 -1150 {
lab=#net17}
N 1860 -1150 1860 -1110 {
lab=#net17}
N 2000 -1150 2000 -1110 {
lab=#net17}
N 2080 -1170 2080 -1110 {
lab=#net16}
N 1780 -1170 2080 -1170 {
lab=#net16}
N 1780 -1170 1780 -1110 {
lab=#net16}
N 2020 -1110 2020 -1010 {
lab=GND}
N 1840 -1010 2020 -1010 {
lab=GND}
N 1840 -1110 1840 -1010 {
lab=GND}
N 1930 -1110 1930 -1010 {
lab=GND}
N 2080 -1110 2100 -1110 {
lab=#net16}
N 2130 -1150 2130 -1140 {
lab=GND}
N 2130 -1150 2170 -1150 {
lab=GND}
N 2170 -1150 2170 -1110 {
lab=GND}
N 2160 -1110 2170 -1110 {
lab=GND}
N 2130 -1110 2130 -1100 {
lab=GND}
N 2130 -1100 2170 -1100 {
lab=GND}
N 2170 -1110 2170 -1100 {
lab=GND}
N 2170 -1100 2170 -1090 {
lab=GND}
N 1760 -1110 1780 -1110 {
lab=#net16}
N 1730 -1110 1730 -1100 {
lab=GND}
N 1690 -1100 1730 -1100 {
lab=GND}
N 1690 -1110 1700 -1110 {
lab=GND}
N 1730 -1150 1730 -1140 {
lab=GND}
N 1690 -1150 1730 -1150 {
lab=GND}
N 1830 -740 1830 -700 {
lab=#net20}
N 1940 -740 1940 -700 {
lab=#net21}
N 1670 -670 1670 -640 {
lab=#net22}
N 1670 -640 1700 -640 {
lab=#net22}
N 1700 -640 1700 -620 {
lab=#net22}
N 1700 -720 1700 -700 {
lab=#net20}
N 1700 -720 1830 -720 {
lab=#net20}
N 1670 -770 1670 -670 {
lab=#net22}
N 1670 -770 1800 -770 {
lab=#net22}
N 1800 -770 1910 -770 {
lab=#net22}
N 2080 -640 2080 -630 {
lab=#net23}
N 2080 -630 2080 -610 {
lab=#net23}
N 2080 -710 2080 -700 {
lab=#net21}
N 1940 -710 2080 -710 {
lab=#net21}
N 2080 -640 2110 -640 {
lab=#net23}
N 2110 -670 2110 -640 {
lab=#net23}
N 1860 -670 1910 -670 {
lab=#net24}
N 1880 -670 1880 -620 {
lab=#net24}
N 1830 -620 1880 -620 {
lab=#net24}
N 1830 -640 1830 -610 {
lab=#net24}
N 1830 -610 1830 -600 {
lab=#net24}
N 1700 -620 1700 -490 {
lab=#net22}
N 2080 -610 2080 -490 {
lab=#net23}
N 2050 -460 2050 -380 {
lab=Vbn}
N 1670 -460 1670 -380 {
lab=Vbn}
N 1700 -430 1700 -410 {
lab=#net25}
N 2080 -430 2080 -410 {
lab=#net26}
N 2290 -1150 2290 -1140 {
lab=#net27}
N 2370 -1150 2370 -1140 {
lab=#net27}
N 2450 -1150 2450 -1140 {
lab=#net27}
N 2530 -1150 2530 -1140 {
lab=#net27}
N 2290 -1150 2530 -1150 {
lab=#net27}
N 2320 -1110 2340 -1110 {
lab=#net28}
N 2480 -1110 2500 -1110 {
lab=#net29}
N 2260 -1170 2260 -1110 {
lab=#net30}
N 2260 -1170 2560 -1170 {
lab=#net30}
N 2560 -1170 2560 -1110 {
lab=#net30}
N 2400 -1110 2420 -1110 {
lab=GND}
N 2560 -1110 2580 -1110 {
lab=#net30}
N 2610 -1150 2610 -1140 {
lab=GND}
N 2610 -1150 2650 -1150 {
lab=GND}
N 2640 -1110 2650 -1110 {
lab=GND}
N 2610 -1110 2610 -1100 {
lab=GND}
N 2610 -1100 2650 -1100 {
lab=GND}
N 2240 -1110 2260 -1110 {
lab=#net30}
N 2210 -1110 2210 -1100 {
lab=GND}
N 2170 -1100 2210 -1100 {
lab=GND}
N 2170 -1110 2180 -1110 {
lab=GND}
N 2210 -1150 2210 -1140 {
lab=GND}
N 2170 -1150 2210 -1150 {
lab=GND}
N 2770 -1150 2770 -1140 {
lab=#net31}
N 2850 -1150 2850 -1140 {
lab=#net31}
N 2930 -1150 2930 -1140 {
lab=#net31}
N 3010 -1150 3010 -1140 {
lab=#net31}
N 2770 -1150 3010 -1150 {
lab=#net31}
N 2800 -1110 2820 -1110 {
lab=#net32}
N 2960 -1110 2980 -1110 {
lab=#net33}
N 2740 -1170 2740 -1110 {
lab=#net34}
N 2740 -1170 3040 -1170 {
lab=#net34}
N 3040 -1170 3040 -1110 {
lab=#net34}
N 2880 -1110 2900 -1110 {
lab=GND}
N 3040 -1110 3060 -1110 {
lab=#net34}
N 3090 -1150 3090 -1140 {
lab=GND}
N 3090 -1150 3130 -1150 {
lab=GND}
N 3120 -1110 3130 -1110 {
lab=GND}
N 3090 -1110 3090 -1100 {
lab=GND}
N 3090 -1100 3130 -1100 {
lab=GND}
N 2720 -1110 2740 -1110 {
lab=#net34}
N 2690 -1110 2690 -1100 {
lab=GND}
N 2650 -1100 2690 -1100 {
lab=GND}
N 2650 -1110 2650 -1100 {
lab=GND}
N 2650 -1110 2660 -1110 {
lab=GND}
N 2690 -1150 2690 -1140 {
lab=GND}
N 2650 -1150 2690 -1150 {
lab=GND}
N 2650 -1150 2650 -1110 {
lab=GND}
N 2650 -1100 2650 -1090 {
lab=GND}
N 3130 -1150 3130 -1090 {
lab=GND}
N 2410 -1110 2410 -1020 {
lab=GND}
N 2410 -1020 2890 -1020 {
lab=GND}
N 2890 -1110 2890 -1020 {
lab=GND}
N 810 -1350 810 -1270 {
lab=#net17}
N 480 -1290 480 -1250 {
lab=#net16}
N 770 -1310 770 -1250 {
lab=#net16}
N 1920 -1350 1940 -1350 {
lab=#net35}
N 1840 -1350 1860 -1350 {
lab=VDD}
N 2000 -1350 2020 -1350 {
lab=VDD}
N 2010 -1450 2010 -1350 {
lab=VDD}
N 1850 -1450 1850 -1350 {
lab=VDD}
N 1810 -1320 1810 -1310 {
lab=#net30}
N 1810 -1310 2050 -1310 {
lab=#net30}
N 2050 -1320 2050 -1310 {
lab=#net30}
N 1970 -1320 1970 -1310 {
lab=#net30}
N 1890 -1320 1890 -1310 {
lab=#net30}
N 2240 -1350 2260 -1350 {
lab=#net36}
N 2210 -1320 2210 -1310 {
lab=#net36}
N 2370 -1320 2370 -1310 {
lab=#net36}
N 2290 -1320 2290 -1310 {
lab=#net36}
N 2130 -1320 2130 -1310 {
lab=#net36}
N 2130 -1310 2370 -1310 {
lab=#net36}
N 2250 -1350 2250 -1310 {
lab=#net36}
N 2180 -1350 2180 -1290 {
lab=#net37}
N 2180 -1290 2320 -1290 {
lab=#net37}
N 2320 -1350 2320 -1290 {
lab=#net37}
N 2080 -1350 2080 -1290 {
lab=#net37}
N 1930 -1350 1930 -1270 {
lab=#net35}
N 2250 -1540 2250 -1350 {
lab=#net36}
N 2100 -1350 2100 -1270 {
lab=#net35}
N 2340 -1450 2340 -1350 {
lab=GND}
N 2160 -1450 2340 -1450 {
lab=GND}
N 2160 -1450 2160 -1350 {
lab=GND}
N 2340 -1540 2340 -1450 {
lab=GND}
N 1200 -1350 1220 -1350 {
lab=#net38}
N 1280 -1350 1300 -1350 {
lab=#net39}
N 1360 -1350 1380 -1350 {
lab=#net40}
N 1170 -1320 1170 -1310 {
lab=#net30}
N 1250 -1320 1250 -1310 {
lab=#net30}
N 1330 -1320 1330 -1310 {
lab=#net30}
N 1410 -1320 1410 -1310 {
lab=#net30}
N 1520 -1350 1540 -1350 {
lab=#net41}
N 1600 -1350 1620 -1350 {
lab=#net42}
N 1680 -1350 1700 -1350 {
lab=#net43}
N 1490 -1320 1490 -1310 {
lab=#net30}
N 1570 -1320 1570 -1310 {
lab=#net30}
N 1650 -1320 1650 -1310 {
lab=#net30}
N 1730 -1320 1730 -1310 {
lab=#net30}
N 1440 -1350 1460 -1350 {
lab=#net30}
N 1170 -1310 1730 -1310 {
lab=#net30}
N 1450 -1350 1450 -1310 {
lab=#net30}
N 2480 -1350 2500 -1350 {
lab=#net44}
N 2560 -1350 2580 -1350 {
lab=#net45}
N 2640 -1350 2660 -1350 {
lab=#net46}
N 2450 -1320 2450 -1310 {
lab=#net34}
N 2530 -1320 2530 -1310 {
lab=#net34}
N 2610 -1320 2610 -1310 {
lab=#net34}
N 2690 -1320 2690 -1310 {
lab=#net34}
N 2800 -1350 2820 -1350 {
lab=#net47}
N 2880 -1350 2900 -1350 {
lab=#net48}
N 2960 -1350 2980 -1350 {
lab=#net49}
N 2770 -1320 2770 -1310 {
lab=#net34}
N 2850 -1320 2850 -1310 {
lab=#net34}
N 2930 -1320 2930 -1310 {
lab=#net34}
N 3010 -1320 3010 -1310 {
lab=#net34}
N 2720 -1350 2740 -1350 {
lab=#net34}
N 2450 -1310 3010 -1310 {
lab=#net34}
N 2730 -1350 2730 -1310 {
lab=#net34}
N 3040 -1350 3040 -1290 {
lab=#net35}
N 1850 -1450 2010 -1450 {
lab=VDD}
N 440 -1990 440 -1980 {
lab=#net50}
N 440 -1980 680 -1980 {
lab=#net50}
N 680 -1990 680 -1980 {
lab=#net50}
N 600 -1990 600 -1980 {
lab=#net50}
N 520 -1990 520 -1980 {
lab=#net50}
N 550 -2020 570 -2020 {
lab=#net50}
N 560 -2020 560 -1980 {
lab=#net50}
N 470 -2020 490 -2020 {
lab=#net51}
N 630 -2020 650 -2020 {
lab=#net51}
N 480 -2120 480 -2020 {
lab=#net51}
N 480 -2120 640 -2120 {
lab=#net51}
N 640 -2120 640 -2020 {
lab=#net51}
N 410 -2020 410 -1960 {
lab=#net52}
N 410 -1960 710 -1960 {
lab=#net52}
N 710 -2020 710 -1960 {
lab=#net52}
N 920 -1990 920 -1980 {
lab=#net52}
N 920 -1980 1160 -1980 {
lab=#net52}
N 1160 -1990 1160 -1980 {
lab=#net52}
N 1080 -1990 1080 -1980 {
lab=#net52}
N 1000 -1990 1000 -1980 {
lab=#net52}
N 1030 -2020 1050 -2020 {
lab=#net53}
N 950 -2020 970 -2020 {
lab=#net54}
N 1110 -2020 1130 -2020 {
lab=#net54}
N 960 -2120 960 -2020 {
lab=#net54}
N 960 -2120 1120 -2120 {
lab=#net54}
N 1120 -2120 1120 -2020 {
lab=#net54}
N 890 -2020 890 -1960 {
lab=#net55}
N 890 -1960 1190 -1960 {
lab=#net55}
N 1190 -2020 1190 -1960 {
lab=#net55}
N 760 -1820 760 -1810 {
lab=#net55}
N 790 -1780 810 -1780 {
lab=#net56}
N 840 -1820 840 -1810 {
lab=#net55}
N 710 -1780 730 -1780 {
lab=#net55}
N 870 -1780 890 -1780 {
lab=#net55}
N 920 -1820 920 -1810 {
lab=#net55}
N 680 -1820 680 -1810 {
lab=#net55}
N 550 -1780 570 -1780 {
lab=#net55}
N 630 -1780 650 -1780 {
lab=#net56}
N 600 -1820 600 -1810 {
lab=#net55}
N 520 -1820 520 -1810 {
lab=#net55}
N 1030 -1780 1050 -1780 {
lab=#net55}
N 1080 -1820 1080 -1810 {
lab=#net55}
N 1000 -1820 1000 -1810 {
lab=#net55}
N 950 -1780 970 -1780 {
lab=#net56}
N 490 -1780 490 -1680 {
lab=#net56}
N 490 -1680 1110 -1680 {
lab=#net56}
N 1110 -1780 1110 -1680 {
lab=#net56}
N 960 -1780 960 -1680 {
lab=#net56}
N 800 -1780 800 -1680 {
lab=#net56}
N 640 -1780 640 -1680 {
lab=#net56}
N 560 -1820 560 -1780 {
lab=#net55}
N 720 -1820 720 -1780 {
lab=#net55}
N 880 -1820 880 -1780 {
lab=#net55}
N 1040 -1820 1040 -1780 {
lab=#net55}
N 470 -1780 470 -1620 {
lab=#net57}
N 470 -1620 1130 -1620 {
lab=#net57}
N 1130 -1780 1130 -1620 {
lab=#net57}
N 440 -1820 440 -1810 {
lab=#net55}
N 1160 -1820 1160 -1810 {
lab=#net55}
N 440 -1820 1160 -1820 {
lab=#net55}
N 1190 -1840 1190 -1780 {
lab=#net50}
N 410 -1840 1190 -1840 {
lab=#net50}
N 410 -1840 410 -1780 {
lab=#net50}
N 560 -1980 560 -1840 {
lab=#net50}
N 360 -2060 360 -2050 {
lab=VDD}
N 320 -2060 360 -2060 {
lab=VDD}
N 320 -2060 320 -2020 {
lab=VDD}
N 320 -2020 330 -2020 {
lab=VDD}
N 360 -2020 360 -2010 {
lab=VDD}
N 320 -2010 360 -2010 {
lab=VDD}
N 320 -2020 320 -2010 {
lab=VDD}
N 320 -2070 320 -2060 {
lab=VDD}
N 390 -2020 410 -2020 {
lab=#net52}
N 1190 -2020 1210 -2020 {
lab=#net55}
N 1240 -2060 1240 -2050 {
lab=VDD}
N 1240 -2060 1280 -2060 {
lab=VDD}
N 1280 -2060 1280 -2020 {
lab=VDD}
N 1270 -2020 1280 -2020 {
lab=VDD}
N 1240 -2020 1240 -2010 {
lab=VDD}
N 1240 -2010 1280 -2010 {
lab=VDD}
N 1280 -2020 1280 -2010 {
lab=VDD}
N 1280 -2070 1280 -2060 {
lab=VDD}
N 390 -1780 410 -1780 {
lab=#net50}
N 360 -1780 360 -1770 {
lab=GND}
N 320 -1770 360 -1770 {
lab=GND}
N 320 -1780 320 -1770 {
lab=GND}
N 320 -1780 330 -1780 {
lab=GND}
N 360 -1820 360 -1810 {
lab=GND}
N 320 -1820 360 -1820 {
lab=GND}
N 320 -1820 320 -1780 {
lab=GND}
N 320 -1770 320 -1760 {
lab=GND}
N 1190 -1780 1210 -1780 {
lab=#net50}
N 1240 -1820 1240 -1810 {
lab=GND}
N 1240 -1820 1280 -1820 {
lab=GND}
N 1280 -1820 1280 -1780 {
lab=GND}
N 1270 -1780 1280 -1780 {
lab=GND}
N 1240 -1780 1240 -1770 {
lab=GND}
N 1240 -1770 1280 -1770 {
lab=GND}
N 1280 -1780 1280 -1770 {
lab=GND}
N 1280 -1770 1280 -1760 {
lab=GND}
N 840 -2060 840 -2050 {
lab=VDD}
N 800 -2060 840 -2060 {
lab=VDD}
N 800 -2020 810 -2020 {
lab=VDD}
N 840 -2020 840 -2010 {
lab=VDD}
N 800 -2010 840 -2010 {
lab=VDD}
N 870 -2020 890 -2020 {
lab=#net55}
N 710 -2020 730 -2020 {
lab=#net52}
N 760 -2060 760 -2050 {
lab=VDD}
N 760 -2060 800 -2060 {
lab=VDD}
N 800 -2060 800 -2020 {
lab=VDD}
N 790 -2020 800 -2020 {
lab=VDD}
N 760 -2020 760 -2010 {
lab=VDD}
N 760 -2010 800 -2010 {
lab=VDD}
N 800 -2020 800 -2010 {
lab=VDD}
N 800 -2070 800 -2060 {
lab=VDD}
N 890 -1960 890 -1820 {
lab=#net55}
N 1400 -1820 1400 -1810 {
lab=#net53}
N 1640 -1820 1640 -1810 {
lab=#net53}
N 1480 -1820 1480 -1810 {
lab=#net53}
N 1510 -1780 1530 -1780 {
lab=#net58}
N 1560 -1820 1560 -1810 {
lab=#net53}
N 1400 -1820 1640 -1820 {
lab=#net53}
N 1450 -1820 1450 -1780 {
lab=#net53}
N 1590 -1820 1590 -1780 {
lab=#net53}
N 1670 -1840 1670 -1780 {
lab=#net52}
N 1370 -1840 1670 -1840 {
lab=#net52}
N 1370 -1840 1370 -1780 {
lab=#net52}
N 1610 -1780 1610 -1680 {
lab=#net58}
N 1430 -1680 1610 -1680 {
lab=#net58}
N 1430 -1780 1430 -1680 {
lab=#net58}
N 1520 -1780 1520 -1680 {
lab=#net58}
N 1670 -1780 1690 -1780 {
lab=#net52}
N 1720 -1820 1720 -1810 {
lab=GND}
N 1720 -1820 1760 -1820 {
lab=GND}
N 1760 -1820 1760 -1780 {
lab=GND}
N 1750 -1780 1760 -1780 {
lab=GND}
N 1720 -1780 1720 -1770 {
lab=GND}
N 1720 -1770 1760 -1770 {
lab=GND}
N 1760 -1780 1760 -1770 {
lab=GND}
N 1760 -1770 1760 -1760 {
lab=GND}
N 1350 -1780 1370 -1780 {
lab=#net52}
N 1320 -1780 1320 -1770 {
lab=GND}
N 1280 -1770 1320 -1770 {
lab=GND}
N 1280 -1780 1290 -1780 {
lab=GND}
N 1320 -1820 1320 -1810 {
lab=GND}
N 1280 -1820 1320 -1820 {
lab=GND}
N 1910 -1820 1910 -1810 {
lab=#net59}
N 1990 -1820 1990 -1810 {
lab=#net59}
N 2070 -1820 2070 -1810 {
lab=#net59}
N 2150 -1820 2150 -1810 {
lab=#net59}
N 1910 -1820 2150 -1820 {
lab=#net59}
N 1940 -1780 1960 -1780 {
lab=#net60}
N 2100 -1780 2120 -1780 {
lab=#net61}
N 1880 -1840 1880 -1780 {
lab=#net62}
N 1880 -1840 2180 -1840 {
lab=#net62}
N 2180 -1840 2180 -1780 {
lab=#net62}
N 2020 -1780 2040 -1780 {
lab=#net63}
N 2180 -1780 2200 -1780 {
lab=#net62}
N 2230 -1820 2230 -1810 {
lab=GND}
N 2230 -1820 2270 -1820 {
lab=GND}
N 2260 -1780 2270 -1780 {
lab=GND}
N 2230 -1780 2230 -1770 {
lab=GND}
N 2230 -1770 2270 -1770 {
lab=GND}
N 1860 -1780 1880 -1780 {
lab=#net62}
N 1830 -1780 1830 -1770 {
lab=GND}
N 1790 -1770 1830 -1770 {
lab=GND}
N 1790 -1780 1790 -1770 {
lab=GND}
N 1790 -1780 1800 -1780 {
lab=GND}
N 1830 -1820 1830 -1810 {
lab=GND}
N 1790 -1820 1830 -1820 {
lab=GND}
N 1790 -1820 1790 -1780 {
lab=GND}
N 1790 -1770 1790 -1760 {
lab=GND}
N 2390 -1820 2390 -1810 {
lab=#net64}
N 2470 -1820 2470 -1810 {
lab=#net64}
N 2550 -1820 2550 -1810 {
lab=#net64}
N 2630 -1820 2630 -1810 {
lab=#net64}
N 2390 -1820 2630 -1820 {
lab=#net64}
N 2420 -1780 2440 -1780 {
lab=#net65}
N 2580 -1780 2600 -1780 {
lab=#net66}
N 2360 -1840 2360 -1780 {
lab=#net67}
N 2360 -1840 2660 -1840 {
lab=#net67}
N 2660 -1840 2660 -1780 {
lab=#net67}
N 2500 -1780 2520 -1780 {
lab=#net63}
N 2660 -1780 2680 -1780 {
lab=#net67}
N 2710 -1820 2710 -1810 {
lab=GND}
N 2710 -1820 2750 -1820 {
lab=GND}
N 2740 -1780 2750 -1780 {
lab=GND}
N 2710 -1780 2710 -1770 {
lab=GND}
N 2710 -1770 2750 -1770 {
lab=GND}
N 2340 -1780 2360 -1780 {
lab=#net67}
N 2310 -1780 2310 -1770 {
lab=GND}
N 2270 -1770 2310 -1770 {
lab=GND}
N 2270 -1780 2270 -1770 {
lab=GND}
N 2270 -1780 2280 -1780 {
lab=GND}
N 2310 -1820 2310 -1810 {
lab=GND}
N 2270 -1820 2310 -1820 {
lab=GND}
N 2270 -1820 2270 -1780 {
lab=GND}
N 2270 -1770 2270 -1760 {
lab=GND}
N 2750 -1820 2750 -1760 {
lab=GND}
N 2030 -1780 2030 -1690 {
lab=#net63}
N 2030 -1690 2510 -1690 {
lab=#net63}
N 2510 -1780 2510 -1690 {
lab=#net63}
N 1040 -2020 1040 -1940 {
lab=#net53}
N 1040 -1940 1520 -1940 {
lab=#net53}
N 1520 -1940 1520 -1820 {
lab=#net53}
N 1370 -1920 1370 -1840 {
lab=#net52}
N 710 -1920 1370 -1920 {
lab=#net52}
N 710 -1960 710 -1920 {
lab=#net52}
N 1000 -1980 1000 -1920 {
lab=#net52}
N 2100 -2020 2120 -2020 {
lab=#net68}
N 2020 -2020 2040 -2020 {
lab=VDD}
N 2180 -2020 2200 -2020 {
lab=VDD}
N 2190 -2120 2190 -2020 {
lab=VDD}
N 2030 -2120 2030 -2020 {
lab=VDD}
N 1990 -1990 1990 -1980 {
lab=#net62}
N 1990 -1980 2230 -1980 {
lab=#net62}
N 2230 -1990 2230 -1980 {
lab=#net62}
N 2150 -1990 2150 -1980 {
lab=#net62}
N 2070 -1990 2070 -1980 {
lab=#net62}
N 2420 -2020 2440 -2020 {
lab=#net69}
N 2390 -1990 2390 -1980 {
lab=#net69}
N 2550 -1990 2550 -1980 {
lab=#net69}
N 2470 -1990 2470 -1980 {
lab=#net69}
N 2310 -1990 2310 -1980 {
lab=#net69}
N 2310 -1980 2550 -1980 {
lab=#net69}
N 2430 -2020 2430 -1980 {
lab=#net69}
N 2360 -2020 2360 -1960 {
lab=#net70}
N 2360 -1960 2500 -1960 {
lab=#net70}
N 2500 -2020 2500 -1960 {
lab=#net70}
N 2260 -2020 2260 -1960 {
lab=#net70}
N 1960 -2020 1960 -1960 {
lab=#net70}
N 1960 -1960 2260 -1960 {
lab=#net70}
N 2260 -1960 2360 -1960 {
lab=#net70}
N 2110 -2020 2110 -1940 {
lab=#net68}
N 2430 -2210 2430 -2020 {
lab=#net69}
N 2280 -2020 2280 -1940 {
lab=#net68}
N 2580 -2020 2580 -1940 {
lab=#net68}
N 2280 -1940 2580 -1940 {
lab=#net68}
N 2520 -2120 2520 -2020 {
lab=GND}
N 2340 -2120 2520 -2120 {
lab=GND}
N 2340 -2120 2340 -2020 {
lab=GND}
N 2520 -2210 2520 -2120 {
lab=GND}
N 2110 -1940 2280 -1940 {
lab=#net68}
N 1370 -2020 1390 -2020 {
lab=#net71}
N 1450 -2020 1470 -2020 {
lab=#net72}
N 1530 -2020 1550 -2020 {
lab=#net73}
N 1340 -1990 1340 -1980 {
lab=#net62}
N 1420 -1990 1420 -1980 {
lab=#net62}
N 1500 -1990 1500 -1980 {
lab=#net62}
N 1580 -1990 1580 -1980 {
lab=#net62}
N 1690 -2020 1710 -2020 {
lab=#net74}
N 1770 -2020 1790 -2020 {
lab=#net75}
N 1850 -2020 1870 -2020 {
lab=#net76}
N 1660 -1990 1660 -1980 {
lab=#net62}
N 1740 -1990 1740 -1980 {
lab=#net62}
N 1820 -1990 1820 -1980 {
lab=#net62}
N 1900 -1990 1900 -1980 {
lab=#net62}
N 1610 -2020 1630 -2020 {
lab=#net62}
N 1340 -1980 1900 -1980 {
lab=#net62}
N 1620 -2020 1620 -1980 {
lab=#net62}
N 1310 -2020 1310 -1960 {
lab=#net70}
N 1310 -1960 1930 -1960 {
lab=#net70}
N 1930 -2020 1930 -1960 {
lab=#net70}
N 2670 -2020 2690 -2020 {
lab=#net77}
N 2750 -2020 2770 -2020 {
lab=#net78}
N 2830 -2020 2850 -2020 {
lab=#net79}
N 2640 -1990 2640 -1980 {
lab=#net67}
N 2720 -1990 2720 -1980 {
lab=#net67}
N 2800 -1990 2800 -1980 {
lab=#net67}
N 2880 -1990 2880 -1980 {
lab=#net67}
N 2990 -2020 3010 -2020 {
lab=#net80}
N 3070 -2020 3090 -2020 {
lab=#net81}
N 3150 -2020 3170 -2020 {
lab=#net82}
N 2960 -1990 2960 -1980 {
lab=#net67}
N 3040 -1990 3040 -1980 {
lab=#net67}
N 3120 -1990 3120 -1980 {
lab=#net67}
N 3200 -1990 3200 -1980 {
lab=#net67}
N 2910 -2020 2930 -2020 {
lab=#net67}
N 2640 -1980 3200 -1980 {
lab=#net67}
N 2920 -2020 2920 -1980 {
lab=#net67}
N 2610 -2020 2610 -1960 {
lab=#net68}
N 2610 -1960 3230 -1960 {
lab=#net68}
N 3230 -2020 3230 -1960 {
lab=#net68}
N 1900 -1980 1900 -1840 {
lab=#net62}
N 2640 -1980 2640 -1840 {
lab=#net67}
N 2030 -2120 2190 -2120 {
lab=VDD}
N 1990 -1980 1990 -1840 {
lab=#net62}
N 1930 -1960 1960 -1960 {
lab=#net70}
N 2580 -1960 2610 -1960 {
lab=#net68}
N 960 -1110 980 -1110 {
lab=#net18}
N 1010 -1150 1010 -1140 {
lab=#net18}
N 930 -1150 930 -1140 {
lab=#net18}
N 880 -1110 900 -1110 {
lab=#net19}
N 890 -1110 890 -1010 {
lab=#net19}
N 970 -1150 970 -1110 {
lab=#net18}
N 1120 -1110 1140 -1110 {
lab=#net18}
N 1170 -1150 1170 -1140 {
lab=#net18}
N 1090 -1150 1090 -1140 {
lab=#net18}
N 1040 -1110 1060 -1110 {
lab=#net19}
N 1050 -1110 1050 -1010 {
lab=#net19}
N 1130 -1150 1130 -1110 {
lab=#net18}
N 1280 -1110 1300 -1110 {
lab=#net18}
N 1330 -1150 1330 -1140 {
lab=#net18}
N 1250 -1150 1250 -1140 {
lab=#net18}
N 1200 -1110 1220 -1110 {
lab=#net19}
N 1210 -1110 1210 -1010 {
lab=#net19}
N 1290 -1150 1290 -1110 {
lab=#net18}
N 1440 -1110 1460 -1110 {
lab=#net18}
N 1490 -1150 1490 -1140 {
lab=#net18}
N 1410 -1150 1410 -1140 {
lab=#net18}
N 1360 -1110 1380 -1110 {
lab=#net19}
N 1370 -1110 1370 -1010 {
lab=#net19}
N 1450 -1150 1450 -1110 {
lab=#net18}
N 1520 -1110 1520 -1010 {
lab=#net19}
N 260 -1010 1520 -1010 {
lab=#net19}
N 210 -1150 1570 -1150 {
lab=#net18}
N 240 -950 1540 -950 {
lab=GND}
N 180 -1170 1600 -1170 {
lab=#net15}
N 1050 -1350 1060 -1350 {
lab=VDD}
N 1050 -1340 1090 -1340 {
lab=VDD}
N 1090 -1350 1090 -1340 {
lab=VDD}
N 1090 -1390 1090 -1380 {
lab=VDD}
N 1050 -1390 1090 -1390 {
lab=VDD}
N 1120 -1350 1140 -1350 {
lab=#net37}
N 1760 -1350 1780 -1350 {
lab=#net37}
N 1790 -1290 2080 -1290 {
lab=#net37}
N 2400 -1350 2420 -1350 {
lab=#net35}
N 1770 -1350 1770 -1290 {
lab=#net37}
N 2080 -1290 2180 -1290 {
lab=#net37}
N 2410 -1350 2410 -1290 {
lab=#net35}
N 480 -1190 1780 -1190 {
lab=#net16}
N 770 -1250 770 -1190 {
lab=#net16}
N 480 -1250 480 -1190 {
lab=#net16}
N 1780 -1190 1780 -1170 {
lab=#net16}
N 810 -1210 1810 -1210 {
lab=#net17}
N 810 -1270 810 -1210 {
lab=#net17}
N 1810 -1210 1810 -1150 {
lab=#net17}
N 1730 -1310 1730 -1230 {
lab=#net30}
N 2260 -1230 2260 -1170 {
lab=#net30}
N 1810 -1310 1810 -1230 {
lab=#net30}
N 1930 -1270 2410 -1270 {
lab=#net35}
N 2410 -1290 2410 -1270 {
lab=#net35}
N 2410 -1290 3040 -1290 {
lab=#net35}
N 2770 -1310 2770 -1170 {
lab=#net34}
N 3040 -1350 3060 -1350 {
lab=#net35}
N 3090 -1390 3090 -1380 {
lab=VDD}
N 3090 -1390 3130 -1390 {
lab=VDD}
N 3130 -1390 3130 -1350 {
lab=VDD}
N 3120 -1350 3130 -1350 {
lab=VDD}
N 3090 -1350 3090 -1340 {
lab=VDD}
N 3090 -1340 3130 -1340 {
lab=VDD}
N 3130 -1350 3130 -1340 {
lab=VDD}
N 3130 -1400 3130 -1390 {
lab=VDD}
N 1130 -1450 1130 -1350 {
lab=#net37}
N 1130 -1450 1770 -1450 {
lab=#net37}
N 1770 -1450 1770 -1350 {
lab=#net37}
N 1770 -1290 1790 -1290 {
lab=#net37}
N 1730 -1230 2260 -1230 {
lab=#net30}
C {madvlsi/pmos3.sym} 770 -2560 2 0 {name=M21
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 770 -2470 2 0 {name=M22
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=8
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/resistor.sym} 770 -2410 0 0 {name=R3
value=700k
m=1}
C {madvlsi/nmos3.sym} 890 -2470 0 0 {name=M23
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 990 -2470 2 0 {name=M24
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1110 -2470 0 0 {name=M25
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 890 -2560 2 0 {name=M26
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 990 -2560 0 0 {name=M27
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1110 -2560 0 0 {name=M28
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 940 -2370 0 0 {name=l5 lab=GND}
C {madvlsi/vdd.sym} 910 -2600 0 0 {name=l23 lab=VDD}
C {devices/lab_pin.sym} 1120 -2510 2 0 {name=p27 sig_type=std_logic lab=Vbn}
C {madvlsi/pmos3.sym} 1320 -2760 3 0 {name=M1
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1320 -2540 1 0 {name=M9
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/resistor.sym} 1440 -2500 0 0 {name=R1
value=700k
m=1}
C {madvlsi/pmos3.sym} 1400 -2760 3 0 {name=M2
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1480 -2760 3 0 {name=M3
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1560 -2760 3 0 {name=M4
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1730 -2760 3 0 {name=M5
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1810 -2760 3 0 {name=M6
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1890 -2760 3 0 {name=M7
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1970 -2760 3 0 {name=M8
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1400 -2540 1 0 {name=M10
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1480 -2540 1 0 {name=M11
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1560 -2540 1 0 {name=M12
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1730 -2540 1 0 {name=M13
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1810 -2540 1 0 {name=M14
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1890 -2540 1 0 {name=M15
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1970 -2540 1 0 {name=M16
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 520 -2920 1 0 {name=M18
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 600 -2920 1 0 {name=M19
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 680 -2920 1 0 {name=M29
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 440 -2920 1 0 {name=M17
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 360 -2920 1 0 {name=M20
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 280 -2920 1 0 {name=M30
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 840 -2920 1 0 {name=M31
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 760 -2920 1 0 {name=M32
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 200 -2920 1 0 {name=M33
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 920 -2920 1 0 {name=M34
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/resistor.sym} 560 -2790 0 0 {name=R2
value=700k
m=1}
C {madvlsi/pmos3.sym} 210 -1350 3 0 {name=M35
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 290 -1350 3 0 {name=M37
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 370 -1350 3 0 {name=M38
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 450 -1350 3 0 {name=M39
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 690 -1350 3 0 {name=M40
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 770 -1350 3 0 {name=M41
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 850 -1350 3 0 {name=M42
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 930 -1350 3 0 {name=M43
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 530 -1110 1 0 {name=M36
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 610 -1110 1 0 {name=M44
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 690 -1110 1 0 {name=M45
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 450 -1110 1 0 {name=M46
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 370 -1110 1 0 {name=M47
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 290 -1110 1 0 {name=M48
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 850 -1110 1 0 {name=M49
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 770 -1110 1 0 {name=M50
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 210 -1110 1 0 {name=M51
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1570 -1110 1 0 {name=M52
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/resistor.sym} 890 -980 0 0 {name=R4
value=700k
m=1}
C {madvlsi/pmos4.sym} 130 -1350 1 0 {name=M1e
L=\{L\}
W=\{W/2\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 1050 -1400 0 0 {name=l22 lab=VDD}
C {madvlsi/vdd.sym} 90 -1400 0 0 {name=l1 lab=VDD}
C {madvlsi/nmos4.sym} 130 -1110 1 0 {name=M53
L=\{L\}
W=\{W/2\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 90 -1090 0 0 {name=l24 lab=GND}
C {madvlsi/gnd.sym} 1690 -1090 0 0 {name=l3 lab=GND}
C {madvlsi/vdd.sym} 570 -1400 0 0 {name=l2 lab=VDD}
C {madvlsi/nmos3.sym} 1810 -1110 1 0 {name=M57
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1890 -1110 1 0 {name=M58
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1970 -1110 1 0 {name=M59
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2050 -1110 1 0 {name=M60
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2170 -1090 0 0 {name=l4 lab=GND}
C {madvlsi/ammeter2.sym} 1940 -640 0 0 {name=Vout}
C {madvlsi/pmos3.sym} 1830 -770 0 0 {name=M63
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1940 -770 0 0 {name=M64
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1830 -670 2 0 {name=M65
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1940 -670 0 0 {name=M66
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1700 -670 0 0 {name=M67
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2080 -670 2 0 {name=M68
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 1830 -800 0 0 {name=l28 lab=VDD}
C {madvlsi/vdd.sym} 1940 -800 0 0 {name=l29 lab=VDD}
C {madvlsi/gnd.sym} 1940 -630 0 0 {name=l30 lab=GND}
C {devices/lab_pin.sym} 1670 -460 0 0 {name=p1 sig_type=std_logic lab=Vbn
}
C {madvlsi/nmos3.sym} 1700 -460 0 0 {name=M69
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 2050 -460 0 0 {name=p3 sig_type=std_logic lab=Vbn
}
C {madvlsi/nmos3.sym} 2080 -460 0 0 {name=M70
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1700 -380 0 0 {name=M71
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2080 -380 0 0 {name=M72
L=\{L\}
W=\{W\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1700 -350 0 0 {name=l6 lab=GND}
C {madvlsi/gnd.sym} 2080 -350 0 0 {name=l7 lab=GND}
C {madvlsi/nmos4.sym} 1730 -1110 1 0 {name=M54
L=\{L\}
W=\{W/2\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos4.sym} 1650 -1110 1 0 {name=M62
L=\{L\}
W=\{W/2\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos4.sym} 2130 -1110 1 0 {name=M61
L=\{L\}
W=\{W/2\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos4.sym} 2210 -1110 1 0 {name=M77
L=\{L\}
W=\{W/2\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos4.sym} 2610 -1110 1 0 {name=M78
L=\{L\}
W=\{W/2\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos4.sym} 530 -1350 1 0 {name=M55
L=\{L\}
W=\{W/2\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos4.sym} 610 -1350 1 0 {name=M56
L=\{L\}
W=\{W/2\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos4.sym} 1010 -1350 1 0 {name=M80
L=\{L\}
W=\{W/2\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2650 -1090 0 0 {name=l8 lab=GND}
C {madvlsi/nmos4.sym} 2690 -1110 1 0 {name=M84
L=\{L\}
W=\{W/2\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos4.sym} 3090 -1110 1 0 {name=M85
L=\{L\}
W=\{W/2\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 3130 -1090 0 0 {name=l10 lab=GND}
C {madvlsi/nmos3.sym} 2290 -1110 1 0 {name=M73
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2370 -1110 1 0 {name=M74
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2450 -1110 1 0 {name=M75
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2530 -1110 1 0 {name=M76
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2770 -1110 1 0 {name=M79
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2850 -1110 1 0 {name=M81
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2930 -1110 1 0 {name=M82
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3010 -1110 1 0 {name=M83
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1810 -1350 3 0 {name=M86
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1890 -1350 3 0 {name=M87
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1970 -1350 3 0 {name=M88
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2050 -1350 3 0 {name=M89
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2130 -1350 3 0 {name=M90
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2210 -1350 3 0 {name=M91
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2290 -1350 3 0 {name=M92
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2370 -1350 3 0 {name=M93
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2340 -1540 2 0 {name=l11 lab=GND}
C {madvlsi/pmos3.sym} 1170 -1350 3 0 {name=M94
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1250 -1350 3 0 {name=M95
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1330 -1350 3 0 {name=M96
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1410 -1350 3 0 {name=M97
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1490 -1350 3 0 {name=M98
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1570 -1350 3 0 {name=M99
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1650 -1350 3 0 {name=M100
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1730 -1350 3 0 {name=M101
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2450 -1350 3 0 {name=M102
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2530 -1350 3 0 {name=M103
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2610 -1350 3 0 {name=M104
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2690 -1350 3 0 {name=M105
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2770 -1350 3 0 {name=M106
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2850 -1350 3 0 {name=M107
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2930 -1350 3 0 {name=M108
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3010 -1350 3 0 {name=M109
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 1850 -1450 0 0 {name=l12 lab=VDD}
C {madvlsi/pmos3.sym} 440 -2020 3 0 {name=M110
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 520 -2020 3 0 {name=M111
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 600 -2020 3 0 {name=M112
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 680 -2020 3 0 {name=M113
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 920 -2020 3 0 {name=M114
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1000 -2020 3 0 {name=M115
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1080 -2020 3 0 {name=M116
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1160 -2020 3 0 {name=M117
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 760 -1780 1 0 {name=M118
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 840 -1780 1 0 {name=M119
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 920 -1780 1 0 {name=M120
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 680 -1780 1 0 {name=M121
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 600 -1780 1 0 {name=M122
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 520 -1780 1 0 {name=M123
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1080 -1780 1 0 {name=M124
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1000 -1780 1 0 {name=M125
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 440 -1780 1 0 {name=M126
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1160 -1780 1 0 {name=M127
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/resistor.sym} 800 -1650 0 0 {name=R5
value=700k
m=1}
C {madvlsi/pmos4.sym} 360 -2020 1 0 {name=M128
L=\{L\}
W=\{W/2\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 1280 -2070 0 0 {name=l13 lab=VDD}
C {madvlsi/vdd.sym} 320 -2070 0 0 {name=l14 lab=VDD}
C {madvlsi/nmos4.sym} 360 -1780 1 0 {name=M129
L=\{L\}
W=\{W/2\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 320 -1760 0 0 {name=l15 lab=GND}
C {madvlsi/gnd.sym} 1280 -1760 0 0 {name=l16 lab=GND}
C {madvlsi/vdd.sym} 800 -2070 0 0 {name=l17 lab=VDD}
C {madvlsi/nmos3.sym} 1400 -1780 1 0 {name=M130
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1480 -1780 1 0 {name=M131
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1560 -1780 1 0 {name=M132
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1640 -1780 1 0 {name=M133
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1760 -1760 0 0 {name=l18 lab=GND}
C {madvlsi/gnd.sym} 1790 -1760 0 0 {name=l19 lab=GND}
C {madvlsi/nmos4.sym} 1320 -1780 1 0 {name=M134
L=\{L\}
W=\{W/2\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos4.sym} 1240 -1780 1 0 {name=M135
L=\{L\}
W=\{W/2\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos4.sym} 1720 -1780 1 0 {name=M136
L=\{L\}
W=\{W/2\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos4.sym} 1830 -1780 1 0 {name=M137
L=\{L\}
W=\{W/2\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos4.sym} 2230 -1780 1 0 {name=M138
L=\{L\}
W=\{W/2\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos4.sym} 760 -2020 1 0 {name=M139
L=\{L\}
W=\{W/2\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos4.sym} 840 -2020 1 0 {name=M140
L=\{L\}
W=\{W/2\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos4.sym} 1240 -2020 1 0 {name=M141
L=\{L\}
W=\{W/2\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2270 -1760 0 0 {name=l20 lab=GND}
C {madvlsi/nmos4.sym} 2310 -1780 1 0 {name=M142
L=\{L\}
W=\{W/2\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos4.sym} 2710 -1780 1 0 {name=M143
L=\{L\}
W=\{W/2\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2750 -1760 0 0 {name=l21 lab=GND}
C {madvlsi/nmos3.sym} 1910 -1780 1 0 {name=M144
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1990 -1780 1 0 {name=M145
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2070 -1780 1 0 {name=M146
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2150 -1780 1 0 {name=M147
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2390 -1780 1 0 {name=M148
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2470 -1780 1 0 {name=M149
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2550 -1780 1 0 {name=M150
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2630 -1780 1 0 {name=M151
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1990 -2020 3 0 {name=M152
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2070 -2020 3 0 {name=M153
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2150 -2020 3 0 {name=M154
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2230 -2020 3 0 {name=M155
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2310 -2020 3 0 {name=M156
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2390 -2020 3 0 {name=M157
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2470 -2020 3 0 {name=M158
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2550 -2020 3 0 {name=M159
L=\{L\}
W=\{W/2\}
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 2520 -2210 2 0 {name=l25 lab=GND}
C {madvlsi/pmos3.sym} 1340 -2020 3 0 {name=M160
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1420 -2020 3 0 {name=M161
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1500 -2020 3 0 {name=M162
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1580 -2020 3 0 {name=M163
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1660 -2020 3 0 {name=M164
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1740 -2020 3 0 {name=M165
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1820 -2020 3 0 {name=M166
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1900 -2020 3 0 {name=M167
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2640 -2020 3 0 {name=M168
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2720 -2020 3 0 {name=M169
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2800 -2020 3 0 {name=M170
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2880 -2020 3 0 {name=M171
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2960 -2020 3 0 {name=M172
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3040 -2020 3 0 {name=M173
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3120 -2020 3 0 {name=M174
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3200 -2020 3 0 {name=M175
L=\{L\}
W=\{W\}
body=VDD
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 2030 -2120 0 0 {name=l26 lab=VDD}
C {madvlsi/nmos3.sym} 1010 -1110 1 0 {name=M176
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 930 -1110 1 0 {name=M177
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1170 -1110 1 0 {name=M178
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1090 -1110 1 0 {name=M179
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1330 -1110 1 0 {name=M180
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1250 -1110 1 0 {name=M181
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1490 -1110 1 0 {name=M182
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1410 -1110 1 0 {name=M183
L=\{L\}
W=\{W/2\}
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 240 -950 0 0 {name=l27 lab=GND}
C {madvlsi/pmos4.sym} 1090 -1350 1 0 {name=M184
L=\{L\}
W=\{W/2\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 3130 -1400 0 0 {name=l31 lab=VDD}
C {madvlsi/pmos4.sym} 3090 -1350 1 0 {name=M185
L=\{L\}
W=\{W/2\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 1840 -1010 0 0 {name=l32 lab=GND}
C {madvlsi/gnd.sym} 2410 -1020 0 0 {name=l33 lab=GND}
C {madvlsi/vdd.sym} 330 -1450 0 0 {name=l34 lab=VDD}
C {madvlsi/vdd.sym} 810 -1450 0 0 {name=l35 lab=VDD}
