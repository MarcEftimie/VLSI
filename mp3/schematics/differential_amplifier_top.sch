v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {madvlsi/vdd.sym} 180 70 0 0 {name=l2 lab=VDD}
C {madvlsi/gnd.sym} 180 170 0 0 {name=l4 lab=GND}
C {/home/madvlsi/Documents/VLSI/mp3/schematics/differential_amplifier.sym} 60 190 0 0 {name=X1}
C {devices/ipin.sym} 160 100 0 0 {name=p1 lab=V1}
C {devices/ipin.sym} 160 140 0 0 {name=p3 lab=V2}
C {devices/iopin.sym} 200 170 1 0 {name=p2 lab=IB}
C {devices/opin.sym} 240 120 0 0 {name=p4 lab=VOUT}
